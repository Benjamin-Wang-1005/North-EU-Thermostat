# Keil uVision project IAP_Bootloader.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: FT32F103RC FMD
  pack: FMD.FT32F1xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP_Bootloader +hex
  AfterMake: fromelf.exe --bin --output=.\Objects\IAP_Bootloader.bin .\Objects\IAP_Bootloader.axf
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\USER;..\USER\IAP;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\FLASH
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../PROJECT/RTE/Device/STM32F103RC/: startup_stm32f10x_hd.s
  group USER
    ../USER/IAP/: iap_main.c
  group IAP
    ../USER/IAP/: iap_flash.c iap_uart.c menu.c ymodem.c common.c set_msp.s
  group CMSIS
    ../PROJECT/RTE/Device/STM32F103RC/: system_stm32f10x.c
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_bkp.c
