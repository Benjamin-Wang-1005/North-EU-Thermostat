# Keil uVision project TOUCH.uvprojx, settings and files
target Thermostat APP (6240000::V6.24::ARMCLANG)
  device: FT32F103RC FMD
  pack: FMD.FT32F1xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  AfterMake: FromELF --bin -o ..\Obj\TOUCH.bin ..\Obj\TOUCH.axf
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\LCD;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\TSensor;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\RTC;..\HARDWARE\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x3b800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: GUI.c main.c stm32f10x_it.c system_stm32f10x.c test.c UI.c Board_init.c Thermostat.h Schedule_UI.c Control_UI.c User_Setting_UI.c Peripheral.c ADC.c Factory_test.c Language.c Adaptive_Start.c
    ../STM32F10x_FWLib/src/: stm32f10x_tim.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/RTC/: rtc_driver.c
    ../STM32F10x_FWLib/src/: stm32f10x_usart.c
    ../HARDWARE/FLASH/: flash_storage.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
software components: CMSIS:CORE 6.4.0, Device:Startup 1.0.0
